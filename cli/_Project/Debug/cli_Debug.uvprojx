# Keil uVision project cli_Debug.uvprojx, settings and files
target Cli (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F405VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cli_Debug +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG
  c include: ..\..\_Code\_App;..\..\_Code\_App\inc;..\..\_Code\_App\src;..\..\_Code\_Bsp\inc;..\..\_Code\_Bsp\src;..\..\_Code\_Hal\inc;..\..\_Code\_Hal\src;..\..\_Code\FreeRTOS\Demo\CORTEX_M4F_STM32F407ZG-SK;..\..\_Code\FreeRTOS\Source;..\..\_Code\FreeRTOS\Source\include;..\..\_Code\FreeRTOS\Source\portable\MemMang;..\..\_Code\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\_Code\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\_Code\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates;..\..\_Code\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\..\_Code\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\CMSIS\Include;..\..\_Code\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\_Code\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\STM32F4xx_StdPeriph_Driver\src;..\..\_Code\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Project
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../../_Code/_App/: main.c
    ../../_Code/_App/src/: cli_task.c cli_register.c
  group Hal
    ../../_Code/_Hal/src/: serial.c
  group Bsp
    ../../_Code/_Bsp/src/: usart.c
  group FreeRTOS
    ../../_Code/FreeRTOS/Source/: tasks.c queue.c list.c
    ../../_Code/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../_Code/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../_Code/FreeRTOS/Demo/CORTEX_M4F_STM32F407ZG-SK/: FreeRTOSConfig.h
  group F4xx_StdPeriph_Lib
    ../../_Code/STM32F4xx_DSP_StdPeriph_Lib_V1.8.0/Project/: stm32f4xx_it.c stm32f4xx_conf.h
    ../../_Code/STM32F4xx_DSP_StdPeriph_Lib_V1.8.0/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
    ../../_Code/STM32F4xx_DSP_StdPeriph_Lib_V1.8.0/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../_Code/STM32F4xx_DSP_StdPeriph_Lib_V1.8.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
