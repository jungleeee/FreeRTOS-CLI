# Keil uVision project cli_Debug.uvprojx, settings and files
target Cli (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F405VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cli_Debug +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG,FreeRTOS
  c include: ..\..\_Code\_App;..\..\_Code\_App\inc;..\..\_Code\_App\src;..\..\_Code\_Bsp\inc;..\..\_Code\_Bsp\src;..\..\_Code\_Hal\inc;..\..\_Code\_Hal\src;..\..\_Code\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\_Code\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates;..\..\_Code\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\..\_Code\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\CMSIS\Include;..\..\_Code\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\_Code\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\STM32F4xx_StdPeriph_Driver\src;..\..\_Code\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Project;..\..\_Code\uCOS-III\Cfg;..\..\_Code\uCOS-III\Cfg\Template;..\..\_Code\uCOS-III\Cpu;..\..\_Code\uCOS-III\Source;..\..\_Code\uCOS-III\TLS;..\..\_Code\uCOS-III\TLS\CCES;..\..\_Code\uCOS-III\TLS\IAR
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../../_Code/_App/: main.c
    ../../_Code/_App/src/: cli_register.c cli_task.c
  group Hal
    ../../_Code/_Hal/src/: serial.c led.c
  group Bsp
    ../../_Code/_Bsp/src/: usart.c gpio.c
  group UcOSIII
    ../../_Code/uCOS-III/Cfg/Template/: os_app_hooks.c
    ../../_Code/uCOS-III/Source/: os_cfg_app.c os_cpu_c.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_mutex.c os_msg.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c os_cpu_a.asm
    ../../_Code/uCOS-III/Cpu/: cpu_c.c cpu_core.c cpu_a.asm
  group F4xx_StdPeriph_Lib
    ../../_Code/STM32F4xx_DSP_StdPeriph_Lib_V1.8.0/Project/: stm32f4xx_it.c stm32f4xx_conf.h
    ../../_Code/STM32F4xx_DSP_StdPeriph_Lib_V1.8.0/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
    ../../_Code/STM32F4xx_DSP_StdPeriph_Lib_V1.8.0/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../_Code/STM32F4xx_DSP_StdPeriph_Lib_V1.8.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
