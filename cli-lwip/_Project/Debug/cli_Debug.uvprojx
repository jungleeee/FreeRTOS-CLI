# Keil uVision project cli_Debug.uvprojx, settings and files
target Cli (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cli_Debug +hex
  AfterMake: fromelf -c -o "$L@L.txt" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG
  c include: ..\..\_Code\_App;..\..\_Code\_App\cli;..\..\_Code\_App\led;..\..\_Code\_App\network;..\..\_Code\_Bsp;..\..\_Code\_Bsp\inc;..\..\_Code\_Bsp\src;..\..\_Code\_Hal;..\..\_Code\_Hal\inc;..\..\_Code\_Hal\src;..\..\_Code\FreeRTOS\Demo\CORTEX_M4F_STM32F407ZG-SK;..\..\_Code\FreeRTOS\Source;..\..\_Code\FreeRTOS\Source\include;..\..\_Code\FreeRTOS\Source\portable\MemMang;..\..\_Code\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\_Code\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\_Code\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates;..\..\_Code\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\..\_Code\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\CMSIS\Include;..\..\_Code\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\STM32F4x7_ETH_Driver;..\..\_Code\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\STM32F4x7_ETH_Driver\inc;..\..\_Code\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\STM32F4x7_ETH_Driver\src;..\..\_Code\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\_Code\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Libraries\STM32F4xx_StdPeriph_Driver\src;..\..\_Code\STM32F4xx_DSP_StdPeriph_Lib_V1.8.0\Project;..\..\_Code\cm_backtrace;..\..\_Code\LWIP;..\..\_Code\LWIP\src;..\..\_Code\LWIP\src\api;..\..\_Code\LWIP\src\core;..\..\_Code\LWIP\src\core\ipv4;..\..\_Code\LWIP\src\core\ipv6;..\..\_Code\LWIP\src\include;..\..\_Code\LWIP\src\include\lwip;..\..\_Code\LWIP\src\include\lwip\apps;..\..\_Code\LWIP\src\include\lwip\priv;..\..\_Code\LWIP\src\include\lwip\prot;..\..\_Code\LWIP\src\include\netif;..\..\_Code\LWIP\src\include\netif\ppp;..\..\_Code\LWIP\src\include\netif\ppp\polarssl;..\..\_Code\LWIP\src\include\posix;..\..\_Code\LWIP\src\include\posix\sys;..\..\_Code\LWIP\src\netif;..\..\_Code\LWIP\src\netif\ppp;..\..\_Code\LWIP\src\netif\ppp\polarssl;..\..\_Code\LWIP\arch
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\cli.sct
  group Start
    ../../_Code/STM32F4xx_DSP_StdPeriph_Lib_V1.8.0/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
    ../../_Code/_App/: main.c
  group Led
    ../../_Code/_App/led/: led_task.c
  group Cli
    ../../_Code/_App/cli/: cli_task.c cli_register.c
  group Network
    ../../_Code/_App/network/: net_tcp.c
  group Hal
    ../../_Code/_Hal/src/: serial.c led.c network.c
  group Bsp
    ../../_Code/_Bsp/src/: usart.c gpio.c stm32f4x7_eth_bsp.c
  group FreeRTOS
    ../../_Code/FreeRTOS/Source/: tasks.c queue.c list.c croutine.c timers.c
    ../../_Code/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../_Code/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../_Code/FreeRTOS/Demo/CORTEX_M4F_STM32F407ZG-SK/: FreeRTOSConfig.h
  group LWIP
    ../../_Code/LWIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../_Code/LWIP/src/core/ipv4/: dhcp.c autoip.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c etharp.c
    ../../_Code/LWIP/src/core/: dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c inet_chksum.c ip.c def.c timeouts.c
    ../../_Code/LWIP/src/netif/: ethernet.c
    ../../_Code/LWIP/arch/: ethernetif.c sys_arch.c
  group F4xx_StdPeriph_Lib
    ../../_Code/STM32F4xx_DSP_StdPeriph_Lib_V1.8.0/Project/: stm32f4xx_it.c stm32f4xx_conf.h
    ../../_Code/STM32F4xx_DSP_StdPeriph_Lib_V1.8.0/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../_Code/STM32F4xx_DSP_StdPeriph_Lib_V1.8.0/Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
    ../../_Code/STM32F4xx_DSP_StdPeriph_Lib_V1.8.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_syscfg.c
  group Backtrace
    ../../_Code/cm_backtrace/: cm_backtrace.c
    ../../_Code/cm_backtrace/fault_handler/keil/: cmb_fault.s
